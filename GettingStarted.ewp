# IAR project GettingStarted.ewp, settings and files
configuration RAM Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ; board\; ..\library\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\library\STM32F10x_StdPeriph_Driver\inc\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: GettingStarted.out
  ILINK.IlinkIcfFile: config\STM32F10x_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash Debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EMB_FLASH; STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCOptLevel: 1
  ILINK.IlinkIcfFile: config\STM32F10x_FLASH.icf
  group (top)
    ./: main.c main.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group CMSIS
    ../library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
    ../library/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Other
    ./: readme.txt
    config/: STM32F10x_FLASH.icf STM32F10x_RAM.icf
  group StdPeriph_Driver
    ../library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
